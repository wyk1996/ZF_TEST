# Keil uVision project code.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F415CBT7 ArteryTek
  pack: ArteryTek.AT32F415_DFP.2.0.7
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: code +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F415CBT7,USE_STDPERIPH_DRIVER, AT_START_F415_V1_0,__TARGET_FPU_SOFTVFP
  c include: ..\pro;..\app;..\bsp\4G;..\bsp\AT32_Board;..\bsp\charge_pro;..\bsp\common;..\bsp\dl654;..\bsp\driver;..\bsp\dwin;..\bsp\rc522;..\bsp\w25qxx;..\lib\AT32F4xx_StdPeriph_Driver\inc;..\lib\CMSIS\CM4\CoreSupport;..\lib\CMSIS\CM4\DeviceSupport;..\third-party\UCOSIII\uC-CPU;..\third-party\UCOSIII\uC-LIB;..\third-party\UCOSIII\uC-CPU\ARM-Cortex-M4\RealView;..\third-party\UCOSIII\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\third-party\UCOSIII\uCOS-III\Source;..\third-party\UCOSIII\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;..\third-party\UCOSIII\EvalBoards\BSP;..\third-party\UCOSIII\EvalBoards\uCOS-III
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group pro
    ../lib/CMSIS/CM4/DeviceSupport/startup/mdk/: startup_at32f415cbt7.s
  group app
    ../app/: at32f4xx_it.c main.c system_at32f4xx.c
    ../bsp/AT32_Board/: at32_board.c
  group bsp
    ../bsp/4G/: 4GMain.c 4GRecv.c 4GSend.c APFrame.c HYFrame.c ModuleA7680C.c YKCFrame.c ZFFrame.c
    ../bsp/charge_pro/: ch_port.c chproc.c chtask.c cp.c
    ../bsp/common/: mq_service.c
    ../bsp/dl654/: dlt645_port.c
    ../bsp/driver/: 485_1.c adc.c delay.c device.c ertc.c HLW8112-SPI.c rc522.c spi_flash.c SPI1.c timer.c uart1.c uart2.c
    ../bsp/dwin/: Dispkey.c DispkeyFunction.c DispShowStatus.c dwin_com_pro.c DwinProtocol.c MenuDisp .c
    ../bsp/rc522/: read_nuid.c
    ../bsp/w25qxx/: flashdispos.c
  group lib
    ../lib/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_acc.c at32f4xx_adc.c at32f4xx_bkp.c at32f4xx_can.c at32f4xx_comp.c at32f4xx_crc.c at32f4xx_dac.c at32f4xx_dbgmcu.c at32f4xx_dma.c at32f4xx_ertc.c at32f4xx_eth.c at32f4xx_exti.c at32f4xx_flash.c at32f4xx_gpio.c at32f4xx_gpio_ex.c at32f4xx_i2c.c at32f4xx_iwdg.c at32f4xx_pwr.c at32f4xx_rcc.c at32f4xx_rtc.c at32f4xx_sdio.c at32f4xx_spi.c at32f4xx_syscfg.c at32f4xx_tim.c at32f4xx_usart.c at32f4xx_wwdg.c at32f4xx_xmc.c misc.c
  group ucos_port
    ../third-party/UCOSIII/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu_c.c os_cpu_a.asm
  group ucos_lib
    ../third-party/UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../third-party/UCOSIII/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group ucos_src
    ../third-party/UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group ucos_bsp
    ../third-party/UCOSIII/EvalBoards/BSP/: bsp.c bsp_int.c bsp_periph.c
  group ucos_cpu
    ../third-party/UCOSIII/uC-CPU/: cpu_core.c
    ../third-party/UCOSIII/uC-CPU/ARM-Cortex-M4/RealView/: cpu_a.asm cpu_c.c
software components: CMSIS:CORE 5.4.0
